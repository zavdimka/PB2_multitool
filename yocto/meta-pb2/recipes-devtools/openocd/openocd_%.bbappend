FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-jtag-add-pb2-pru-adapter.patch"
